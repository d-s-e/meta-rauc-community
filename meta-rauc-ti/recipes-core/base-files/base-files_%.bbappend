FILESEXTRAPATHS:prepend:ti-soc := "${THISDIR}/files:"
